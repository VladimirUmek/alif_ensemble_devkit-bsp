# Keil uVision project HTTPS_Server.uvprojx, settings and files
target DevKit-E7 (6220000::V6.22::ARMCLANG)
  device: AE722F80F55D5LS:M55_HE Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.1.2.1
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x58000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ELITTLE
  output: HTTPS_Server
  AfterMake: fromelf.exe --bin Objects\HTTPS_Server.axf --output Objects\HTTPS_Server.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CMSIS_target_header=\"DevKit-E7.h\"
  c include: ./ConductorTool;./
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x58000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\RTE\Device\AE722F80F55D5LS_M55_HE\M55_HE.sct
  group Source
    ./: HTTPS_Server.c HTTPS_Server_CGI.c
    ./Web/: Web.c
  group Board
    ./: main.c retarget_stdio.c DevKit-E7.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Security:mbed TLS 3.6.0, BSP:External peripherals:Ethernet PHY 1.1.0, Device:Conductor Tool support 1.1.0, Device:Retarget IO:STDERR 1.1.0, Device:Retarget IO:STDIN 1.1.0, Device:Retarget IO:STDOUT 1.1.0, Device:SOC Peripherals:Ethernet MAC 1.1.0, Device:SOC Peripherals:PINCONF 1.1.0, Device:SOC Peripherals:USART 1.1.0, Device:Startup 1.1.0, CMSIS Driver:GPIO 1.0.0, CMSIS Driver:VIO:Board 1.0.0, Network:CORE 8.0.0, Network:Interface:ETH 8.0.0, Network:Service:Web Server Compact 8.0.0, Network:Socket:TCP 8.0.0, Network:Socket:UDP 8.0.0
